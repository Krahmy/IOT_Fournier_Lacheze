# Keil uVision project Lora.sx1276mb1las.uvprojx, settings and files
target sx1276mb1las (ARM-ADS)
  device: STM32L072CZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NUCLEO_CUBE_LORA.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 wLevel=3
  c define: __MICROLIB STM32L072xx USE_STM32L0XX_NUCLEO USE_HAL_DRIVER USE_SHT REGION_EU868
  c misc: -xc -Wno-packed -Wno-missing-variable-declarations -Wno-missing-prototypes -Wno-missing-noreturn -Wno-nonportable-include-path -Wno-reserved-id-macro -Wno-unused-macros -Wno-documentation-unknown-command -Wno-documentation -Wno-license-management -Wno-parentheses-equality -Wno-reserved-identifier
  c include: C:/Users/oksta/AppData/Local/Arm/Packs/Keil/STM32L0xx_DFP/2.2.0/Device/Include;../../inc;../../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Middlewares/Third_Party/Lora/Crypto;../../../../../../../Middlewares/Third_Party/Lora/Mac;../../../../../../../Middlewares/Third_Party/Lora/Phy;../../../../../../../Middlewares/Third_Party/Lora/Utilities;../../../../../../../Middlewares/Third_Party/Lora/Core;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Drivers/BSP/Components/sx1276;../../../../../../../Drivers/BSP/sx1276mb1las;../../../../../../../Drivers/BSP/Components/flash_eraseprogram;../../../../../../../Drivers/BSP/Components/ds18b20;../../../../../../../Drivers/BSP/Components/gpio_exti;../../../../../../../Drivers/BSP/Components/oil_float;../../../../../../../Drivers/BSP/Components/sht20;../../../../../../../Drivers/BSP/Components/pwr_out;../../../../../../../Drivers/BSP/Components/sht31;../../../../../../../Drivers/BSP/Components/ult;../../../../../../../Drivers/BSP/Components/lidar_lite_v3hp;../../../../../../../Drivers/BSP/Components/weight;../../../../../../../Drivers/BSP/Components/iwdg;../../../../../../../Drivers/BSP/Components/bh1750;../../../../../../../Drivers/BSP/Components/tfsensor;../../../../../../../Drivers/BSP/Components/hyt939;../../../../../../../Drivers/BSP/Components/hc2a
  asm define: STM32L072xx USE_STM32L0XX_NUCLEO USE_HAL_DRIVER USE_SHT REGION_EU868
  asm misc: --diag_suppress=A1950W
  asm include: :/Users/oksta/AppData/Local/Arm/Packs/Keil/STM32L0xx_DFP/2.2.0/Device/Include;../../inc;../../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Middlewares/Third_Party/Lora/Crypto;../../../../../../../Middlewares/Third_Party/Lora/Mac;../../../../../../../Middlewares/Third_Party/Lora/Phy;../../../../../../../Middlewares/Third_Party/Lora/Utilities;../../../../../../../Middlewares/Third_Party/Lora/Core;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Drivers/BSP/Components/sx1276;../../../../../../../Drivers/BSP/sx1276mb1las;../../../../../../../Drivers/BSP/Components/flash_eraseprogram;../../../../../../../Drivers/BSP/Components/ds18b20;../../../../../../../Drivers/BSP/Components/gpio_exti;../../../../../../../Drivers/BSP/Components/oil_float;../../../../../../../Drivers/BSP/Components/sht20;../../../../../../../Drivers/BSP/Components/pwr_out;../../../../../../../Drivers/BSP/Components/sht31;../../../../../../../Drivers/BSP/Components/ult;../../../../../../../Drivers/BSP/Components/lidar_lite_v3hp;../../../../../../../Drivers/BSP/Components/weight;../../../../../../../Drivers/BSP/Components/iwdg;../../../../../../../Drivers/BSP/Components/bh1750;../../../../../../../Drivers/BSP/Components/tfsensor;../../../../../../../Drivers/BSP/Components/hyt939;../../../../../../../Drivers/BSP/Components/hc2a
  library: MicroLIB
  memory RVCT4: RAM 0x8000000 size 0x30000
  memory RVCT9: ROM 0x20000000 size 0x5000
  scatter file: ./NUCLEO_CUBE_LORA.sx1276mb1las.sct
  link misc: --summary_stderr --info summarysizes --load_addr_map_info --entry=Reset_Handler
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/flash_eraseprogram/: flash_eraseprogram.c
    ../../../../../../../Drivers/BSP/Components/iwdg/: iwdg.c
    ../../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
    ../../../../../../../Drivers/BSP/Components/pwr_out/: pwr_out.c
    ../../../../../../../Drivers/BSP/Components/gpio_exti/: gpio_exti.c
    ../../../../../../../Drivers/BSP/Components/oil_float/: oil_float.c
    ../../../../../../../Drivers/BSP/Components/ds18b20/: ds18b20.c
    ../../../../../../../Drivers/BSP/Components/sht20/: sht20.c
    ../../../../../../../Drivers/BSP/Components/sht31/: sht31.c
    ../../../../../../../Drivers/BSP/Components/bh1750/: bh1750.c
    ../../../../../../../Drivers/BSP/Components/lidar_lite_v3hp/: lidar_lite_v3hp.c
    ../../../../../../../Drivers/BSP/Components/tfsensor/: tfsensor.c
    ../../../../../../../Drivers/BSP/Components/ult/: ult.c
    ../../../../../../../Drivers/BSP/Components/weight/: weight.c
    ../../../../../../../Drivers/BSP/Components/hyt939/: hyt939.c
    ../../../../../../../Drivers/BSP/Components/hc2a/: hc2a.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/sx1276mb1las
    ../../../../../../../Drivers/BSP/sx1276mb1las/: sx1276mb1las.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_iwdg.c
  group Projects/MDK-ARM
    ./: startup_stm32l072xx.s
  group Projects/End_Node
    ../../src/: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c stm32l0xx_hal_msp.c stm32l0xx_hw.c stm32l0xx_it.c vcom.c at.c command.c lora.c tiny_sscanf.c tiny_vsnprintf.c
  group Middlewares/Lora/Mac/region
    ../../../../../../../Middlewares/Third_Party/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionRU864.c RegionKZ865.c RegionMA869.c
    ../../../../../../../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
    ../../../../../../../Middlewares/Third_Party/Lora/Core/: lora-test.c
  group Middlewares/Lora/Utilities
    ../../../../../../../Middlewares/Third_Party/Lora/Utilities/: delay.c low_power_manager.c timeServer.c utilities.c trace.c queue.c
  group Middlewares/Lora/Crypto
    ../../../../../../../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
